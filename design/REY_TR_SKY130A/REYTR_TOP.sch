v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=AVDD}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=AVSS}
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 400 0 0 0 {name=XXA0}
N 400.0 -40.0 400.0 -20.0 {lab=AVDD}
C {devices/lab_pin.sym} 400.0 -40.0 3 0 {name=l0 sig_type=std_logic lab=AVDD }
N 400.0 40.0 400.0 20.0 {lab=AVSS}
C {devices/lab_pin.sym} 400.0 40.0 1 0 {name=l1 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TIEH_CV.sym} 400 150.0 0 0 {name=XXA1}
N 460.0 110.0 440.0 110.0 {lab=Y1}
C {devices/lab_pin.sym} 460.0 110.0 2 0 {name=l2 sig_type=std_logic lab=Y1 }
N 400.0 50.0 400.0 70.0 {lab=AVDD}
C {devices/lab_pin.sym} 400.0 50.0 3 0 {name=l3 sig_type=std_logic lab=AVDD }
N 400.0 170.0 400.0 150.0 {lab=AVSS}
C {devices/lab_pin.sym} 400.0 170.0 1 0 {name=l4 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TIEL_CV.sym} 400 340.0 0 0 {name=XXA2}
N 460.0 300.0 440.0 300.0 {lab=Y2}
C {devices/lab_pin.sym} 460.0 300.0 2 0 {name=l5 sig_type=std_logic lab=Y2 }
N 400.0 240.0 400.0 260.0 {lab=AVDD}
C {devices/lab_pin.sym} 400.0 240.0 3 0 {name=l6 sig_type=std_logic lab=AVDD }
N 400.0 360.0 400.0 340.0 {lab=AVSS}
C {devices/lab_pin.sym} 400.0 360.0 1 0 {name=l7 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 400 530.0 0 0 {name=XXB0}
N 400.0 490.0 400.0 510.0 {lab=AVDD}
C {devices/lab_pin.sym} 400.0 490.0 3 0 {name=l8 sig_type=std_logic lab=AVDD }
N 400.0 570.0 400.0 550.0 {lab=AVSS}
C {devices/lab_pin.sym} 400.0 570.0 1 0 {name=l9 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_IVX1_CV.sym} 400 680.0 0 0 {name=XXB3}
N 380.0 680.0 400.0 680.0 {lab=A3}
C {devices/lab_pin.sym} 380.0 680.0 0 0 {name=l10 sig_type=std_logic lab=A3 }
N 500.0 680.0 480.0 680.0 {lab=Y3}
C {devices/lab_pin.sym} 500.0 680.0 2 0 {name=l11 sig_type=std_logic lab=Y3 }
N 440.0 620.0 440.0 640.0 {lab=AVDD}
C {devices/lab_pin.sym} 440.0 620.0 3 0 {name=l12 sig_type=std_logic lab=AVDD }
N 440.0 740.0 440.0 720.0 {lab=AVSS}
C {devices/lab_pin.sym} 440.0 740.0 1 0 {name=l13 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_IVX2_CV.sym} 400 870.0 0 0 {name=XXB4}
N 380.0 870.0 400.0 870.0 {lab=A4}
C {devices/lab_pin.sym} 380.0 870.0 0 0 {name=l14 sig_type=std_logic lab=A4 }
N 500.0 870.0 480.0 870.0 {lab=Y4}
C {devices/lab_pin.sym} 500.0 870.0 2 0 {name=l15 sig_type=std_logic lab=Y4 }
N 440.0 810.0 440.0 830.0 {lab=AVDD}
C {devices/lab_pin.sym} 440.0 810.0 3 0 {name=l16 sig_type=std_logic lab=AVDD }
N 440.0 930.0 440.0 910.0 {lab=AVSS}
C {devices/lab_pin.sym} 440.0 930.0 1 0 {name=l17 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_IVX4_CV.sym} 900 0 0 0 {name=XXB5}
N 880.0 0.0 900.0 0.0 {lab=A5}
C {devices/lab_pin.sym} 880.0 0.0 0 0 {name=l18 sig_type=std_logic lab=A5 }
N 1000.0 0.0 980.0 0.0 {lab=Y5}
C {devices/lab_pin.sym} 1000.0 0.0 2 0 {name=l19 sig_type=std_logic lab=Y5 }
N 940.0 -60.0 940.0 -40.0 {lab=AVDD}
C {devices/lab_pin.sym} 940.0 -60.0 3 0 {name=l20 sig_type=std_logic lab=AVDD }
N 940.0 60.0 940.0 40.0 {lab=AVSS}
C {devices/lab_pin.sym} 940.0 60.0 1 0 {name=l21 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_IVX8_CV.sym} 900 190.0 0 0 {name=XXB6}
N 880.0 190.0 900.0 190.0 {lab=A6}
C {devices/lab_pin.sym} 880.0 190.0 0 0 {name=l22 sig_type=std_logic lab=A6 }
N 1000.0 190.0 980.0 190.0 {lab=Y6}
C {devices/lab_pin.sym} 1000.0 190.0 2 0 {name=l23 sig_type=std_logic lab=Y6 }
N 940.0 130.0 940.0 150.0 {lab=AVDD}
C {devices/lab_pin.sym} 940.0 130.0 3 0 {name=l24 sig_type=std_logic lab=AVDD }
N 940.0 250.0 940.0 230.0 {lab=AVSS}
C {devices/lab_pin.sym} 940.0 250.0 1 0 {name=l25 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 900 380.0 0 0 {name=XXC0}
N 900.0 340.0 900.0 360.0 {lab=AVDD}
C {devices/lab_pin.sym} 900.0 340.0 3 0 {name=l26 sig_type=std_logic lab=AVDD }
N 900.0 420.0 900.0 400.0 {lab=AVSS}
C {devices/lab_pin.sym} 900.0 420.0 1 0 {name=l27 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_BFX1_CV.sym} 900 530.0 0 0 {name=XXC7}
N 880.0 530.0 900.0 530.0 {lab=A7}
C {devices/lab_pin.sym} 880.0 530.0 0 0 {name=l28 sig_type=std_logic lab=A7 }
N 1000.0 530.0 980.0 530.0 {lab=Y7}
C {devices/lab_pin.sym} 1000.0 530.0 2 0 {name=l29 sig_type=std_logic lab=Y7 }
N 940.0 470.0 940.0 490.0 {lab=AVDD}
C {devices/lab_pin.sym} 940.0 470.0 3 0 {name=l30 sig_type=std_logic lab=AVDD }
N 940.0 590.0 940.0 570.0 {lab=AVSS}
C {devices/lab_pin.sym} 940.0 590.0 1 0 {name=l31 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 900 720.0 0 0 {name=XXD0}
N 900.0 680.0 900.0 700.0 {lab=AVDD}
C {devices/lab_pin.sym} 900.0 680.0 3 0 {name=l32 sig_type=std_logic lab=AVDD }
N 900.0 760.0 900.0 740.0 {lab=AVSS}
C {devices/lab_pin.sym} 900.0 760.0 1 0 {name=l33 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_NRX1_CV.sym} 900 870.0 0 0 {name=XXD8}
N 880.0 850.0 900.0 850.0 {lab=A8}
C {devices/lab_pin.sym} 880.0 850.0 0 0 {name=l34 sig_type=std_logic lab=A8 }
N 880.0 870.0 900.0 870.0 {lab=B8}
C {devices/lab_pin.sym} 880.0 870.0 0 0 {name=l35 sig_type=std_logic lab=B8 }
N 1010.0 860.0 990.0 860.0 {lab=Y8}
C {devices/lab_pin.sym} 1010.0 860.0 2 0 {name=l36 sig_type=std_logic lab=Y8 }
N 940.0 800.0 940.0 820.0 {lab=AVDD}
C {devices/lab_pin.sym} 940.0 800.0 3 0 {name=l37 sig_type=std_logic lab=AVDD }
N 940.0 920.0 940.0 900.0 {lab=AVSS}
C {devices/lab_pin.sym} 940.0 920.0 1 0 {name=l38 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_NDX1_CV.sym} 1400 0 0 0 {name=XXD9}
N 1380.0 -20.0 1400.0 -20.0 {lab=A9}
C {devices/lab_pin.sym} 1380.0 -20.0 0 0 {name=l39 sig_type=std_logic lab=A9 }
N 1380.0 0.0 1400.0 0.0 {lab=B9}
C {devices/lab_pin.sym} 1380.0 0.0 0 0 {name=l40 sig_type=std_logic lab=B9 }
N 1510.0 -10.0 1490.0 -10.0 {lab=Y9}
C {devices/lab_pin.sym} 1510.0 -10.0 2 0 {name=l41 sig_type=std_logic lab=Y9 }
N 1440.0 -70.0 1440.0 -50.0 {lab=AVDD}
C {devices/lab_pin.sym} 1440.0 -70.0 3 0 {name=l42 sig_type=std_logic lab=AVDD }
N 1440.0 50.0 1440.0 30.0 {lab=AVSS}
C {devices/lab_pin.sym} 1440.0 50.0 1 0 {name=l43 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ORX1_CV.sym} 1400 190.0 0 0 {name=XXD10}
N 1380.0 170.0 1400.0 170.0 {lab=A10}
C {devices/lab_pin.sym} 1380.0 170.0 0 0 {name=l44 sig_type=std_logic lab=A10 }
N 1380.0 190.0 1400.0 190.0 {lab=B10}
C {devices/lab_pin.sym} 1380.0 190.0 0 0 {name=l45 sig_type=std_logic lab=B10 }
N 1510.0 180.0 1490.0 180.0 {lab=Y10}
C {devices/lab_pin.sym} 1510.0 180.0 2 0 {name=l46 sig_type=std_logic lab=Y10 }
N 1440.0 120.0 1440.0 140.0 {lab=AVDD}
C {devices/lab_pin.sym} 1440.0 120.0 3 0 {name=l47 sig_type=std_logic lab=AVDD }
N 1440.0 240.0 1440.0 220.0 {lab=AVSS}
C {devices/lab_pin.sym} 1440.0 240.0 1 0 {name=l48 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ANX1_CV.sym} 1400 380.0 0 0 {name=XXD11}
N 1380.0 360.0 1400.0 360.0 {lab=A11}
C {devices/lab_pin.sym} 1380.0 360.0 0 0 {name=l49 sig_type=std_logic lab=A11 }
N 1380.0 380.0 1400.0 380.0 {lab=B11}
C {devices/lab_pin.sym} 1380.0 380.0 0 0 {name=l50 sig_type=std_logic lab=B11 }
N 1510.0 370.0 1490.0 370.0 {lab=Y11}
C {devices/lab_pin.sym} 1510.0 370.0 2 0 {name=l51 sig_type=std_logic lab=Y11 }
N 1440.0 310.0 1440.0 330.0 {lab=AVDD}
C {devices/lab_pin.sym} 1440.0 310.0 3 0 {name=l52 sig_type=std_logic lab=AVDD }
N 1440.0 430.0 1440.0 410.0 {lab=AVSS}
C {devices/lab_pin.sym} 1440.0 430.0 1 0 {name=l53 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 1400 570.0 0 0 {name=XXE0}
N 1400.0 530.0 1400.0 550.0 {lab=AVDD}
C {devices/lab_pin.sym} 1400.0 530.0 3 0 {name=l54 sig_type=std_logic lab=AVDD }
N 1400.0 610.0 1400.0 590.0 {lab=AVSS}
C {devices/lab_pin.sym} 1400.0 610.0 1 0 {name=l55 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_SCX1_CV.sym} 1400 720.0 0 0 {name=XXE12}
N 1380.0 720.0 1400.0 720.0 {lab=A12}
C {devices/lab_pin.sym} 1380.0 720.0 0 0 {name=l56 sig_type=std_logic lab=A12 }
N 1500.0 720.0 1480.0 720.0 {lab=Y12}
C {devices/lab_pin.sym} 1500.0 720.0 2 0 {name=l57 sig_type=std_logic lab=Y12 }
N 1440.0 660.0 1440.0 680.0 {lab=AVDD}
C {devices/lab_pin.sym} 1440.0 660.0 3 0 {name=l58 sig_type=std_logic lab=AVDD }
N 1440.0 780.0 1440.0 760.0 {lab=AVSS}
C {devices/lab_pin.sym} 1440.0 780.0 1 0 {name=l59 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 1400 910.0 0 0 {name=XXG0}
N 1400.0 870.0 1400.0 890.0 {lab=AVDD}
C {devices/lab_pin.sym} 1400.0 870.0 3 0 {name=l60 sig_type=std_logic lab=AVDD }
N 1400.0 950.0 1400.0 930.0 {lab=AVSS}
C {devices/lab_pin.sym} 1400.0 950.0 1 0 {name=l61 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TGX2_CV.sym} 1900 0 0 0 {name=XXG1}
N 1890.0 0.0 1910.0 0.0 {lab=A16}
C {devices/lab_pin.sym} 1890.0 0.0 0 0 {name=l62 sig_type=std_logic lab=A16 }
N 1960.0 -60.0 1960.0 -40.0 {lab=C16}
C {devices/lab_pin.sym} 1960.0 -60.0 3 0 {name=l63 sig_type=std_logic lab=C16 }
N 2030.0 0.0 2010.0 0.0 {lab=B16}
C {devices/lab_pin.sym} 2030.0 0.0 2 0 {name=l64 sig_type=std_logic lab=B16 }
N 1990.0 -60.0 1990.0 -40.0 {lab=AVDD}
C {devices/lab_pin.sym} 1990.0 -60.0 3 0 {name=l65 sig_type=std_logic lab=AVDD }
N 1990.0 70.0 1990.0 50.0 {lab=AVSS}
C {devices/lab_pin.sym} 1990.0 70.0 1 0 {name=l66 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_RPPO2.sym} 1900 200.0 0 0 {name=XXH1}
N 1880.0 200.0 1900.0 200.0 {lab=P17}
C {devices/lab_pin.sym} 1880.0 200.0 0 0 {name=l67 sig_type=std_logic lab=P17 }
N 2000.0 200.0 1980.0 200.0 {lab=N17}
C {devices/lab_pin.sym} 2000.0 200.0 2 0 {name=l68 sig_type=std_logic lab=N17 }
N 1940.0 240.0 1940.0 220.0 {lab=AVSS}
C {devices/lab_pin.sym} 1940.0 240.0 1 0 {name=l69 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_RPPO4.sym} 1900 330.0 0 0 {name=XXI1}
N 1880.0 330.0 1900.0 330.0 {lab=P18}
C {devices/lab_pin.sym} 1880.0 330.0 0 0 {name=l70 sig_type=std_logic lab=P18 }
N 2000.0 330.0 1980.0 330.0 {lab=N18}
C {devices/lab_pin.sym} 2000.0 330.0 2 0 {name=l71 sig_type=std_logic lab=N18 }
N 1940.0 370.0 1940.0 350.0 {lab=AVSS}
C {devices/lab_pin.sym} 1940.0 370.0 1 0 {name=l72 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_RPPO8.sym} 1900 460.0 0 0 {name=XXJ1}
N 1880.0 460.0 1900.0 460.0 {lab=P19}
C {devices/lab_pin.sym} 1880.0 460.0 0 0 {name=l73 sig_type=std_logic lab=P19 }
N 2000.0 460.0 1980.0 460.0 {lab=N19}
C {devices/lab_pin.sym} 2000.0 460.0 2 0 {name=l74 sig_type=std_logic lab=N19 }
N 1940.0 500.0 1940.0 480.0 {lab=AVSS}
C {devices/lab_pin.sym} 1940.0 500.0 1 0 {name=l75 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_RPPO16.sym} 1900 590.0 0 0 {name=XXK1}
N 1880.0 590.0 1900.0 590.0 {lab=P20}
C {devices/lab_pin.sym} 1880.0 590.0 0 0 {name=l76 sig_type=std_logic lab=P20 }
N 2000.0 590.0 1980.0 590.0 {lab=N20}
C {devices/lab_pin.sym} 2000.0 590.0 2 0 {name=l77 sig_type=std_logic lab=N20 }
N 1940.0 630.0 1940.0 610.0 {lab=AVSS}
C {devices/lab_pin.sym} 1940.0 630.0 1 0 {name=l78 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 1900 720.0 0 0 {name=XXL0}
N 1900.0 680.0 1900.0 700.0 {lab=AVDD}
C {devices/lab_pin.sym} 1900.0 680.0 3 0 {name=l79 sig_type=std_logic lab=AVDD }
N 1900.0 760.0 1900.0 740.0 {lab=AVSS}
C {devices/lab_pin.sym} 1900.0 760.0 1 0 {name=l80 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_CKDIV2_CV.sym} 1900 870.0 0 0 {name=XXL1}
N 1860.0 870.0 1880.0 870.0 {lab=AVDD}
C {devices/lab_pin.sym} 1860.0 870.0 0 0 {name=l81 sig_type=std_logic lab=AVDD }
N 1860.0 890.0 1880.0 890.0 {lab=AVSS}
C {devices/lab_pin.sym} 1860.0 890.0 0 0 {name=l82 sig_type=std_logic lab=AVSS }
N 1860.0 910.0 1880.0 910.0 {lab=CKI21}
C {devices/lab_pin.sym} 1860.0 910.0 0 0 {name=l83 sig_type=std_logic lab=CKI21 }
N 1860.0 930.0 1880.0 930.0 {lab=CKO21}
C {devices/lab_pin.sym} 1860.0 930.0 0 0 {name=l84 sig_type=std_logic lab=CKO21 }
N 1860.0 950.0 1880.0 950.0 {lab=CKO50DC21}
C {devices/lab_pin.sym} 1860.0 950.0 0 0 {name=l85 sig_type=std_logic lab=CKO50DC21 }
N 1860.0 970.0 1880.0 970.0 {lab=RN21}
C {devices/lab_pin.sym} 1860.0 970.0 0 0 {name=l86 sig_type=std_logic lab=RN21 }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 2400 0 0 0 {name=XXM0}
N 2400.0 -40.0 2400.0 -20.0 {lab=AVDD}
C {devices/lab_pin.sym} 2400.0 -40.0 3 0 {name=l87 sig_type=std_logic lab=AVDD }
N 2400.0 40.0 2400.0 20.0 {lab=AVSS}
C {devices/lab_pin.sym} 2400.0 40.0 1 0 {name=l88 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_DFTRIX1_CV.sym} 2400 150.0 0 0 {name=XXM1}
N 2360.0 150.0 2380.0 150.0 {lab=D22}
C {devices/lab_pin.sym} 2360.0 150.0 0 0 {name=l89 sig_type=std_logic lab=D22 }
N 2360.0 170.0 2380.0 170.0 {lab=CK22}
C {devices/lab_pin.sym} 2360.0 170.0 0 0 {name=l90 sig_type=std_logic lab=CK22 }
N 2360.0 190.0 2380.0 190.0 {lab=C22}
C {devices/lab_pin.sym} 2360.0 190.0 0 0 {name=l91 sig_type=std_logic lab=C22 }
N 2360.0 210.0 2380.0 210.0 {lab=CN22}
C {devices/lab_pin.sym} 2360.0 210.0 0 0 {name=l92 sig_type=std_logic lab=CN22 }
N 2360.0 230.0 2380.0 230.0 {lab=Y22}
C {devices/lab_pin.sym} 2360.0 230.0 0 0 {name=l93 sig_type=std_logic lab=Y22 }
N 2360.0 250.0 2380.0 250.0 {lab=AVDD}
C {devices/lab_pin.sym} 2360.0 250.0 0 0 {name=l94 sig_type=std_logic lab=AVDD }
N 2360.0 270.0 2380.0 270.0 {lab=AVSS}
C {devices/lab_pin.sym} 2360.0 270.0 0 0 {name=l95 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_DFTSPCX1_CV.sym} 2400 390.0 0 0 {name=XXM2}
N 2380.0 330.0 2400.0 330.0 {lab=D23}
C {devices/lab_pin.sym} 2380.0 330.0 0 0 {name=l96 sig_type=std_logic lab=D23 }
N 2380.0 390.0 2400.0 390.0 {lab=CK23}
C {devices/lab_pin.sym} 2380.0 390.0 0 0 {name=l97 sig_type=std_logic lab=CK23 }
N 2520.0 330.0 2500.0 330.0 {lab=Q23}
C {devices/lab_pin.sym} 2520.0 330.0 2 0 {name=l98 sig_type=std_logic lab=Q23 }
N 2460.0 280.0 2460.0 300.0 {lab=AVDD}
C {devices/lab_pin.sym} 2460.0 280.0 3 0 {name=l99 sig_type=std_logic lab=AVDD }
N 2460.0 440.0 2460.0 420.0 {lab=AVSS}
C {devices/lab_pin.sym} 2460.0 440.0 1 0 {name=l100 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 2400 620.0 0 0 {name=XXN0}
N 2400.0 580.0 2400.0 600.0 {lab=AVDD}
C {devices/lab_pin.sym} 2400.0 580.0 3 0 {name=l101 sig_type=std_logic lab=AVDD }
N 2400.0 660.0 2400.0 640.0 {lab=AVSS}
C {devices/lab_pin.sym} 2400.0 660.0 1 0 {name=l102 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_DFRNQNX1_CV.sym} 2400 770.0 0 0 {name=XXN2}
N 2380.0 710.0 2400.0 710.0 {lab=D25}
C {devices/lab_pin.sym} 2380.0 710.0 0 0 {name=l103 sig_type=std_logic lab=D25 }
N 2380.0 770.0 2400.0 770.0 {lab=CK25}
C {devices/lab_pin.sym} 2380.0 770.0 0 0 {name=l104 sig_type=std_logic lab=CK25 }
N 2430.0 820.0 2430.0 800.0 {lab=RN25}
C {devices/lab_pin.sym} 2430.0 820.0 1 0 {name=l105 sig_type=std_logic lab=RN25 }
N 2520.0 710.0 2500.0 710.0 {lab=Q25}
C {devices/lab_pin.sym} 2520.0 710.0 2 0 {name=l106 sig_type=std_logic lab=Q25 }
N 2520.0 770.0 2500.0 770.0 {lab=QN25}
C {devices/lab_pin.sym} 2520.0 770.0 2 0 {name=l107 sig_type=std_logic lab=QN25 }
N 2460.0 660.0 2460.0 680.0 {lab=AVDD}
C {devices/lab_pin.sym} 2460.0 660.0 3 0 {name=l108 sig_type=std_logic lab=AVDD }
N 2460.0 820.0 2460.0 800.0 {lab=AVSS}
C {devices/lab_pin.sym} 2460.0 820.0 1 0 {name=l109 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 2400 1000.0 0 0 {name=XXQ0}
N 2400.0 960.0 2400.0 980.0 {lab=AVDD}
C {devices/lab_pin.sym} 2400.0 960.0 3 0 {name=l110 sig_type=std_logic lab=AVDD }
N 2400.0 1040.0 2400.0 1020.0 {lab=AVSS}
C {devices/lab_pin.sym} 2400.0 1040.0 1 0 {name=l111 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ANX2_CV.sym} 2900 0 0 0 {name=XXQ1}
N 2880.0 -20.0 2900.0 -20.0 {lab=A32}
C {devices/lab_pin.sym} 2880.0 -20.0 0 0 {name=l112 sig_type=std_logic lab=A32 }
N 2880.0 0.0 2900.0 0.0 {lab=B32}
C {devices/lab_pin.sym} 2880.0 0.0 0 0 {name=l113 sig_type=std_logic lab=B32 }
N 3010.0 -10.0 2990.0 -10.0 {lab=Y32}
C {devices/lab_pin.sym} 3010.0 -10.0 2 0 {name=l114 sig_type=std_logic lab=Y32 }
N 2940.0 -70.0 2940.0 -50.0 {lab=AVDD}
C {devices/lab_pin.sym} 2940.0 -70.0 3 0 {name=l115 sig_type=std_logic lab=AVDD }
N 2940.0 50.0 2940.0 30.0 {lab=AVSS}
C {devices/lab_pin.sym} 2940.0 50.0 1 0 {name=l116 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ANX4_CV.sym} 2900 190.0 0 0 {name=XXQ2}
N 2880.0 170.0 2900.0 170.0 {lab=A33}
C {devices/lab_pin.sym} 2880.0 170.0 0 0 {name=l117 sig_type=std_logic lab=A33 }
N 2880.0 190.0 2900.0 190.0 {lab=B33}
C {devices/lab_pin.sym} 2880.0 190.0 0 0 {name=l118 sig_type=std_logic lab=B33 }
N 3010.0 180.0 2990.0 180.0 {lab=Y33}
C {devices/lab_pin.sym} 3010.0 180.0 2 0 {name=l119 sig_type=std_logic lab=Y33 }
N 2940.0 120.0 2940.0 140.0 {lab=AVDD}
C {devices/lab_pin.sym} 2940.0 120.0 3 0 {name=l120 sig_type=std_logic lab=AVDD }
N 2940.0 240.0 2940.0 220.0 {lab=AVSS}
C {devices/lab_pin.sym} 2940.0 240.0 1 0 {name=l121 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ANX8_CV.sym} 2900 380.0 0 0 {name=XXQ3}
N 2880.0 360.0 2900.0 360.0 {lab=A34}
C {devices/lab_pin.sym} 2880.0 360.0 0 0 {name=l122 sig_type=std_logic lab=A34 }
N 2880.0 380.0 2900.0 380.0 {lab=B34}
C {devices/lab_pin.sym} 2880.0 380.0 0 0 {name=l123 sig_type=std_logic lab=B34 }
N 3010.0 370.0 2990.0 370.0 {lab=Y34}
C {devices/lab_pin.sym} 3010.0 370.0 2 0 {name=l124 sig_type=std_logic lab=Y34 }
N 2940.0 310.0 2940.0 330.0 {lab=AVDD}
C {devices/lab_pin.sym} 2940.0 310.0 3 0 {name=l125 sig_type=std_logic lab=AVDD }
N 2940.0 430.0 2940.0 410.0 {lab=AVSS}
C {devices/lab_pin.sym} 2940.0 430.0 1 0 {name=l126 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 2900 570.0 0 0 {name=XXR0}
N 2900.0 530.0 2900.0 550.0 {lab=AVDD}
C {devices/lab_pin.sym} 2900.0 530.0 3 0 {name=l127 sig_type=std_logic lab=AVDD }
N 2900.0 610.0 2900.0 590.0 {lab=AVSS}
C {devices/lab_pin.sym} 2900.0 610.0 1 0 {name=l128 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ORX2_CV.sym} 2900 720.0 0 0 {name=XXR1}
N 2880.0 700.0 2900.0 700.0 {lab=A35}
C {devices/lab_pin.sym} 2880.0 700.0 0 0 {name=l129 sig_type=std_logic lab=A35 }
N 2880.0 720.0 2900.0 720.0 {lab=B35}
C {devices/lab_pin.sym} 2880.0 720.0 0 0 {name=l130 sig_type=std_logic lab=B35 }
N 3010.0 710.0 2990.0 710.0 {lab=Y35}
C {devices/lab_pin.sym} 3010.0 710.0 2 0 {name=l131 sig_type=std_logic lab=Y35 }
N 2940.0 650.0 2940.0 670.0 {lab=AVDD}
C {devices/lab_pin.sym} 2940.0 650.0 3 0 {name=l132 sig_type=std_logic lab=AVDD }
N 2940.0 770.0 2940.0 750.0 {lab=AVSS}
C {devices/lab_pin.sym} 2940.0 770.0 1 0 {name=l133 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ORX4_CV.sym} 2900 910.0 0 0 {name=XXR2}
N 2880.0 890.0 2900.0 890.0 {lab=A36}
C {devices/lab_pin.sym} 2880.0 890.0 0 0 {name=l134 sig_type=std_logic lab=A36 }
N 2880.0 910.0 2900.0 910.0 {lab=B36}
C {devices/lab_pin.sym} 2880.0 910.0 0 0 {name=l135 sig_type=std_logic lab=B36 }
N 3010.0 900.0 2990.0 900.0 {lab=Y36}
C {devices/lab_pin.sym} 3010.0 900.0 2 0 {name=l136 sig_type=std_logic lab=Y36 }
N 2940.0 840.0 2940.0 860.0 {lab=AVDD}
C {devices/lab_pin.sym} 2940.0 840.0 3 0 {name=l137 sig_type=std_logic lab=AVDD }
N 2940.0 960.0 2940.0 940.0 {lab=AVSS}
C {devices/lab_pin.sym} 2940.0 960.0 1 0 {name=l138 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_ORX8_CV.sym} 3400 0 0 0 {name=XXR3}
N 3380.0 -20.0 3400.0 -20.0 {lab=A37}
C {devices/lab_pin.sym} 3380.0 -20.0 0 0 {name=l139 sig_type=std_logic lab=A37 }
N 3380.0 0.0 3400.0 0.0 {lab=B37}
C {devices/lab_pin.sym} 3380.0 0.0 0 0 {name=l140 sig_type=std_logic lab=B37 }
N 3510.0 -10.0 3490.0 -10.0 {lab=Y37}
C {devices/lab_pin.sym} 3510.0 -10.0 2 0 {name=l141 sig_type=std_logic lab=Y37 }
N 3440.0 -70.0 3440.0 -50.0 {lab=AVDD}
C {devices/lab_pin.sym} 3440.0 -70.0 3 0 {name=l142 sig_type=std_logic lab=AVDD }
N 3440.0 50.0 3440.0 30.0 {lab=AVSS}
C {devices/lab_pin.sym} 3440.0 50.0 1 0 {name=l143 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 3400 190.0 0 0 {name=XXS0}
N 3400.0 150.0 3400.0 170.0 {lab=AVDD}
C {devices/lab_pin.sym} 3400.0 150.0 3 0 {name=l144 sig_type=std_logic lab=AVDD }
N 3400.0 230.0 3400.0 210.0 {lab=AVSS}
C {devices/lab_pin.sym} 3400.0 230.0 1 0 {name=l145 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_IVTRICX1_CV.sym} 3400 340.0 0 0 {name=XXS1}
N 3360.0 340.0 3380.0 340.0 {lab=A38}
C {devices/lab_pin.sym} 3360.0 340.0 0 0 {name=l146 sig_type=std_logic lab=A38 }
N 3360.0 360.0 3380.0 360.0 {lab=C38}
C {devices/lab_pin.sym} 3360.0 360.0 0 0 {name=l147 sig_type=std_logic lab=C38 }
N 3360.0 380.0 3380.0 380.0 {lab=Y38}
C {devices/lab_pin.sym} 3360.0 380.0 0 0 {name=l148 sig_type=std_logic lab=Y38 }
N 3360.0 400.0 3380.0 400.0 {lab=AVDD}
C {devices/lab_pin.sym} 3360.0 400.0 0 0 {name=l149 sig_type=std_logic lab=AVDD }
N 3360.0 420.0 3380.0 420.0 {lab=AVSS}
C {devices/lab_pin.sym} 3360.0 420.0 0 0 {name=l150 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 3400 540.0 0 0 {name=XXW0}
N 3400.0 500.0 3400.0 520.0 {lab=AVDD}
C {devices/lab_pin.sym} 3400.0 500.0 3 0 {name=l151 sig_type=std_logic lab=AVDD }
N 3400.0 580.0 3400.0 560.0 {lab=AVSS}
C {devices/lab_pin.sym} 3400.0 580.0 1 0 {name=l152 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TGPD_CV.sym} 3400 690.0 0 0 {name=XXW2}
N 3360.0 690.0 3380.0 690.0 {lab=C43}
C {devices/lab_pin.sym} 3360.0 690.0 0 0 {name=l153 sig_type=std_logic lab=C43 }
N 3360.0 710.0 3380.0 710.0 {lab=A43}
C {devices/lab_pin.sym} 3360.0 710.0 0 0 {name=l154 sig_type=std_logic lab=A43 }
N 3360.0 730.0 3380.0 730.0 {lab=B43}
C {devices/lab_pin.sym} 3360.0 730.0 0 0 {name=l155 sig_type=std_logic lab=B43 }
N 3360.0 750.0 3380.0 750.0 {lab=AVDD}
C {devices/lab_pin.sym} 3360.0 750.0 0 0 {name=l156 sig_type=std_logic lab=AVDD }
N 3360.0 770.0 3380.0 770.0 {lab=AVSS}
C {devices/lab_pin.sym} 3360.0 770.0 0 0 {name=l157 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 3400 890.0 0 0 {name=XXT0}
N 3400.0 850.0 3400.0 870.0 {lab=AVDD}
C {devices/lab_pin.sym} 3400.0 850.0 3 0 {name=l158 sig_type=std_logic lab=AVDD }
N 3400.0 930.0 3400.0 910.0 {lab=AVSS}
C {devices/lab_pin.sym} 3400.0 930.0 1 0 {name=l159 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_DFQNX1_CV.sym} 3900 0 0 0 {name=XXT1}
N 3880.0 -60.0 3900.0 -60.0 {lab=D39}
C {devices/lab_pin.sym} 3880.0 -60.0 0 0 {name=l160 sig_type=std_logic lab=D39 }
N 3880.0 0.0 3900.0 0.0 {lab=CK39}
C {devices/lab_pin.sym} 3880.0 0.0 0 0 {name=l161 sig_type=std_logic lab=CK39 }
N 4020.0 -60.0 4000.0 -60.0 {lab=Q39}
C {devices/lab_pin.sym} 4020.0 -60.0 2 0 {name=l162 sig_type=std_logic lab=Q39 }
N 4020.0 0.0 4000.0 0.0 {lab=QN39}
C {devices/lab_pin.sym} 4020.0 0.0 2 0 {name=l163 sig_type=std_logic lab=QN39 }
N 3960.0 -110.0 3960.0 -90.0 {lab=AVDD}
C {devices/lab_pin.sym} 3960.0 -110.0 3 0 {name=l164 sig_type=std_logic lab=AVDD }
N 3960.0 50.0 3960.0 30.0 {lab=AVSS}
C {devices/lab_pin.sym} 3960.0 50.0 1 0 {name=l165 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 3900 230.0 0 0 {name=XXU0}
N 3900.0 190.0 3900.0 210.0 {lab=AVDD}
C {devices/lab_pin.sym} 3900.0 190.0 3 0 {name=l166 sig_type=std_logic lab=AVDD }
N 3900.0 270.0 3900.0 250.0 {lab=AVSS}
C {devices/lab_pin.sym} 3900.0 270.0 1 0 {name=l167 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_EOX1_CV.sym} 3900 380.0 0 0 {name=XXU1}
N 3860.0 380.0 3880.0 380.0 {lab=A40}
C {devices/lab_pin.sym} 3860.0 380.0 0 0 {name=l168 sig_type=std_logic lab=A40 }
N 3860.0 400.0 3880.0 400.0 {lab=B40}
C {devices/lab_pin.sym} 3860.0 400.0 0 0 {name=l169 sig_type=std_logic lab=B40 }
N 3860.0 420.0 3880.0 420.0 {lab=Y40}
C {devices/lab_pin.sym} 3860.0 420.0 0 0 {name=l170 sig_type=std_logic lab=Y40 }
N 3860.0 440.0 3880.0 440.0 {lab=AVDD}
C {devices/lab_pin.sym} 3860.0 440.0 0 0 {name=l171 sig_type=std_logic lab=AVDD }
N 3860.0 460.0 3880.0 460.0 {lab=AVSS}
C {devices/lab_pin.sym} 3860.0 460.0 0 0 {name=l172 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_TAPCELLB_CV.sym} 3900 580.0 0 0 {name=XXV0}
N 3900.0 540.0 3900.0 560.0 {lab=AVDD}
C {devices/lab_pin.sym} 3900.0 540.0 3 0 {name=l173 sig_type=std_logic lab=AVDD }
N 3900.0 620.0 3900.0 600.0 {lab=AVSS}
C {devices/lab_pin.sym} 3900.0 620.0 1 0 {name=l174 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_LSX1_CV.sym} 3900 730.0 0 0 {name=XXV1}
N 3730.0 720.0 3750.0 720.0 {lab=A41}
C {devices/lab_pin.sym} 3730.0 720.0 0 0 {name=l175 sig_type=std_logic lab=A41 }
N 3730.0 740.0 3750.0 740.0 {lab=AN41}
C {devices/lab_pin.sym} 3730.0 740.0 0 0 {name=l176 sig_type=std_logic lab=AN41 }
N 3890.0 740.0 3870.0 740.0 {lab=YN41}
C {devices/lab_pin.sym} 3890.0 740.0 2 0 {name=l177 sig_type=std_logic lab=YN41 }
N 3890.0 720.0 3870.0 720.0 {lab=Y41}
C {devices/lab_pin.sym} 3890.0 720.0 2 0 {name=l178 sig_type=std_logic lab=Y41 }
N 3730.0 700.0 3750.0 700.0 {lab=AVDD}
C {devices/lab_pin.sym} 3730.0 700.0 0 0 {name=l179 sig_type=std_logic lab=AVDD }
N 3730.0 760.0 3750.0 760.0 {lab=AVSS}
C {devices/lab_pin.sym} 3730.0 760.0 0 0 {name=l180 sig_type=std_logic lab=AVSS }
C {REY_TR_SKY130A/REYTR_CAPX1.sym} 3900 900.0 0 0 {name=XXO1}
N 3900.0 820.0 3900.0 840.0 {lab=A26}
C {devices/lab_pin.sym} 3900.0 820.0 3 0 {name=l181 sig_type=std_logic lab=A26 }
N 3900.0 930.0 3900.0 910.0 {lab=B26}
C {devices/lab_pin.sym} 3900.0 930.0 1 0 {name=l182 sig_type=std_logic lab=B26 }
C {REY_TR_SKY130A/REYTR_CAPX1.sym} 4400 0 0 0 {name=XXO0}
N 4400.0 -80.0 4400.0 -60.0 {lab=A27}
C {devices/lab_pin.sym} 4400.0 -80.0 3 0 {name=l183 sig_type=std_logic lab=A27 }
N 4400.0 30.0 4400.0 10.0 {lab=B27}
C {devices/lab_pin.sym} 4400.0 30.0 1 0 {name=l184 sig_type=std_logic lab=B27 }
